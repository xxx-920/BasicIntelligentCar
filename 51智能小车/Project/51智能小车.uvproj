# Keil uVision project 51智能小车.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51智能小车 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Libraries;..\User
  group LIB
    ./: STARTUP.A51
  group USER
    ../User/: main.c
